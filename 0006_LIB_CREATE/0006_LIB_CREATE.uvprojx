# Keil uVision project 0006_LIB_CREATE.uvprojx, settings and files
target STM32F10xC6 (6150000::V6.15::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 0006_LIB_CREATE +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  asm define: USE_STDPERIPH_DRIVER,STM32F1XX,HSE_VALUE=8000000
  asm include: ..\0006_LIB_CREATE
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User App
    ./: main.c
  group User Lib header
    ./: clock_config.h
  group User Lib source
    ./: clock_conf.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
